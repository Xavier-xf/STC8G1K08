# Keil uVision project compare.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: compare +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: compare.c GPIO.c main.c
