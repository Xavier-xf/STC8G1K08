# Keil uVision project STC8G1K08-RESET.uvproj, settings and files
target STC8G1K08-RESET (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(24000000) MODP2
  output: stc8g1k08_reset +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\Driver\inc
  group Source Group 1
    ../User/: main.c
    ../Driver/src/: heartbeat_monitor.c uart.c reset_controller.c maintenance_runtime.c
